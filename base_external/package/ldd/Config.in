## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  ldd package for buildroot. Kernel drivers module-misc and scull.
```
